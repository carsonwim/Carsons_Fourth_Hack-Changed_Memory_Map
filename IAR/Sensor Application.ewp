# IAR project Sensor Application.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430FR5739 MSP430FR5739
  General.GStackSize2: 500
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\CC3000HostDriver; ..\CC3000 Spi; ..\inc
  ICC430.CCOptLevel: 2
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: vee_lnk430fr5739.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../SensorApplication/: board.c cc3000.c demo.c demo_config.h sensors.c server.c strlib.c terminal.c uart.c
  group Libraries
    Debug/Exe/: CC3000 Host Driver.r43 CC3000_Spi.r43
